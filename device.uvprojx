# Keil uVision project device.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: device
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER , HSE_VALUE = 8000000
  c include: .\RTOS\include;.\RTOS\ARM_CM3;.\RTOS;..\fr_sd_spl;.\FatFS;.\FatFS\Third_Party\FatFs\src;.\FatFS\FATFS\App;.\FatFS\FATFS\Target
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c main.h periodic_tasks.c periodic_tasks.h initializes.c initializes.h usart_funcs.c usart_funcs.h defines.h enums.h prio_tasks.c prio_tasks.h esp_funcs.c esp_funcs.h
  group FReeRTos
    ./RTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./RTOS/MemMang/: heap_4.c
    ./RTOS/ARM_CM3/: port.c
  group FatFS
    ./FatFS/: fatfs_sd.c
    ./FatFS/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ./FatFS/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ./FatFS/FATFS/Target/: user_diskio.c
    ./FatFS/FATFS/App/: fatfs.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
